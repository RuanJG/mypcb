File: LED_Part5.sch (KiCad schematic (older format))
At the start: 13 parts

Commit message: Ruan: modify LED part
Parts:
- gave numbers to parts that had none: 13
