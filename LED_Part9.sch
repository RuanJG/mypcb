File: LED_Part9.sch (KiCad schematic (older format))
At the start: 16 parts

Commit message: Ruan: modify LED part
Parts:
- gave numbers to parts that had none: 16
